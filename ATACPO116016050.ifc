Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: C:\Users\Usuario\Desktop\JOMBAR\MUESTRAS B.I.M\IFC\ATLAS\NIVEL 01\ATACPO116016050.ifc
Time: 2017-02-22T20:48:00
Written by: ACCA_IFC.dll Version 200
Made in: Edificius 8.00c

# IfcSite, Default Site
RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey (4)
In: Default Building
Name | Elevation (mm) | NominalHeight (mm)
TERRENO | -1500 | 1000
Cimentación | -500 | 500
Planta Baja | 0 | 3200
Cubierta | 3200 | 0

# IfcFurnishingElement: CALZO ATLAS 01 ACOPLE, CALZO ACOPLE ATLAS
In: Planta Baja
Description: CALZO ACOPLE IPN140; Material: Color_01
PROPIEDADES GENERALES - COMPOSICIÓN: COMPOSITE POLIETILENO; COLOR: NEGRO; TEMPERATURA MÁXIMA ALMACENAMIENTO: 60º C; CARGA MÁXIMA POR cm2: >1000 Kg/cm2; RESISTENCIA A LA COMPRESIÓN: >100 MPa
Pset_ManufacturerTypeInformation - ArticleNumber: CALZO ATLAS 01 ACOPLE IPN 140; ModelReference: ATACPO116016050; ModelLabel: ATACPO116016050; Manufacturer: JOMBAR; ProductionYear: 2017
